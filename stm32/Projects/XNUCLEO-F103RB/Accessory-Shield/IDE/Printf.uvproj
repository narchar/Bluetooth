# Keil uVision project Printf.uvproj, settings and files
target Printf (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Printf +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\..\..\Common;..\..\..\..\Libraries\USART;..\..\..\..\Libraries\STM32F10x_LIB\CMSIS;..\..\..\..\Libraries\STM32F10x_LIB\inc;..\SRC;..\..\..\..\Libraries\delay
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32F10x_LIB
    ../../../../Libraries/STM32F10x_LIB/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ../../../../Libraries/STM32F10x_LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c
  group hardware
    ../../../../Libraries/USART/: USART.c
    ../../../../Libraries/delay/: delay.c
  group user
    ../SRC/: Config.c main.c fifo.c timer.c stm32f10x_it.c JSON.c RGB_LED.c Buzzer.c ADC.c IO_IIC.c LM75b.c DS3231.c ADXL345.c Joystick.c SSD1306.c Fonts.c
